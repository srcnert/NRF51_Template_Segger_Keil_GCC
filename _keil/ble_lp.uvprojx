# Keil uVision project ble_lp.uvprojx, settings and files
target MY_PROJECT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: my_project_v100 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD NRF51822 S130 NRF_SD_BLE_API_VERSION=2 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 NRF_DFU_SETTINGS_VERSION=1
  c include: ..\..\..\components;..\..\..\components\ble\ble_advertising;..\..\..\components\ble\ble_dtm;..\..\..\components\ble\ble_racp;..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\components\ble\ble_services\ble_bas;..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\components\ble\ble_services\ble_cscs;..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\components\ble\ble_services\ble_dfu;..\..\..\components\ble\ble_services\ble_dis;..\..\..\components\ble\ble_services\ble_gls;..\..\..\components\ble\ble_services\ble_hids;..\..\..\components\ble\ble_services\ble_hrs;..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\components\ble\ble_services\ble_hts;..\..\..\components\ble\ble_services\ble_ias;..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\components\ble\ble_services\ble_lbs;..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\components\ble\ble_services\ble_lls;..\..\..\components\ble\ble_services\ble_nus;..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\components\ble\ble_services\ble_rscs;..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\components\ble\ble_services\ble_tps;..\..\..\components\ble\common;..\..\..\components\ble\nrf_ble_gatt;..\..\..\components\ble\nrf_ble_qwr;..\..\..\components\ble\peer_manager;..\..\..\components\boards;..\..\..\components\drivers_nrf\adc;..\..\..\components\drivers_nrf\clock;..\..\..\components\drivers_nrf\common;..\..\..\components\drivers_nrf\comp;..\..\..\components\drivers_nrf\delay;..\..\..\components\drivers_nrf\gpiote;..\..\..\components\drivers_nrf\hal;..\..\..\components\drivers_nrf\i2s;..\..\..\components\drivers_nrf\lpcomp;..\..\..\components\drivers_nrf\pdm;..\..\..\components\drivers_nrf\power;..\..\..\components\drivers_nrf\ppi;..\..\..\components\drivers_nrf\pwm;..\..\..\components\drivers_nrf\qdec;..\..\..\components\drivers_nrf\rng;..\..\..\components\drivers_nrf\rtc;..\..\..\components\drivers_nrf\saadc;..\..\..\components\drivers_nrf\spi_master;..\..\..\components\drivers_nrf\spi_slave;..\..\..\components\drivers_nrf\swi;..\..\..\components\drivers_nrf\timer;..\..\..\components\drivers_nrf\twi_master;..\..\..\components\drivers_nrf\twis_slave;..\..\..\components\drivers_nrf\uart;..\..\..\components\drivers_nrf\usbd;..\..\..\components\drivers_nrf\wdt;..\..\..\components\libraries\bsp;..\..\..\components\libraries\button;..\..\..\components\libraries\crc16;..\..\..\components\libraries\crc32;..\..\..\components\libraries\csense;..\..\..\components\libraries\csense_drv;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\fds;..\..\..\components\libraries\fstorage;..\..\..\components\libraries\gpiote;..\..\..\components\libraries\hardfault;..\..\..\components\libraries\hci;..\..\..\components\libraries\led_softblink;..\..\..\components\libraries\log;..\..\..\components\libraries\log\src;..\..\..\components\libraries\low_power_pwm;..\..\..\components\libraries\mem_manager;..\..\..\components\libraries\pwm;..\..\..\components\libraries\queue;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\sensorsim;..\..\..\components\libraries\slip;..\..\..\components\libraries\timer;..\..\..\components\libraries\twi;..\..\..\components\libraries\uart;..\..\..\components\libraries\usbd;..\..\..\components\libraries\usbd\class\audio;..\..\..\components\libraries\usbd\class\cdc;..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\components\libraries\usbd\class\hid;..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\components\libraries\usbd\class\msc;..\..\..\components\libraries\usbd\config;..\..\..\components\libraries\util;..\..\..\components\softdevice\common\softdevice_handler;..\..\..\components\softdevice\s130\headers;..\..\..\components\softdevice\s130\headers\nrf51;..\..\..\components\toolchain;..\..\..\external\segger_rtt;..\..\..\components\drivers_nrf\pstorage;..\..\..\components\drivers_nrf\pstorage\config;..\..\..\components\libraries\uart;..\..\..\components\libraries\fifo;..\..\..\components\libraries\bootloader\dfu;..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\components\libraries\bootloader;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\crc32;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20002008 size 0x1ff8
  group src
    ../src/: main.c my_ble.c my_fstorage.c my_gpiote.c my_i2c.c my_timer.c my_board.c my_wdt.c
  group inc
    ../inc/: sdk_config.h main.h my_ble.h my_gpiote.h my_i2c.h my_timer.h my_fstorage.h my_board.h my_wdt.h
  group nRF_BLE
    ../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
  group nRF_BLE_Services
    ../../../components/ble/ble_services/ble_dis/: ble_dis.c
  group nRF_Drivers
    ../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../components/drivers_nrf/adc/: nrf_drv_adc.c
    ../../../components/drivers_nrf/hal/: nrf_adc.c
    ../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../components/drivers_nrf/wdt/: nrf_drv_wdt.c
  group nRF_Libraries
    ../../../components/libraries/fifo/: app_fifo.c
    ../../../components/libraries/util/: app_error_weak.c app_error.c nrf_assert.c sdk_errors.c app_util_platform.c sdk_mapped_flags.c
    ../../../components/libraries/crc32/: crc32.c
    ../../../components/libraries/scheduler/: app_scheduler.c
    ../../../components/libraries/timer/: app_timer.c
    ../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../components/libraries/gpiote/: app_gpiote.c
    ../../../components/libraries/fstorage/: fstorage.c
    ../../../components/libraries/uart/: retarget.c app_uart_fifo.c
    ../../../components/libraries/crc16/: crc16.c
    ../../../components/libraries/fds/: fds.c
    ../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_SoftDevice
    ../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
software components: CMSIS:CORE 5.1.2, Device:Startup 8.17.0
